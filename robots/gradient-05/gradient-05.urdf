Commit message: fixed jog error

File: robots/gradient-05/gradient-05.urdf (robot description, URDF)
Before this commit: robot gradient-05, 7 links, 6 joints
Joints:
- joint joint6: limit lower=-6.3 upper=6.3 effort=100 velocity=2.0 -> lower=-10.0 upper=10.0 effort=100 velocity=2.0
